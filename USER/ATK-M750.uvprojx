# Keil uVision project ATK-M750.uvprojx, settings and files
target ATK-M750 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ATK +hex
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\LCD;..\HARDWARE\RingBuffer;..\MALLOC;..\HARDWARE\UART2;..\HARDWARE\ATK-M750;..\MPU6050;..\MPU6050\eMPL;..\HARDWARE\TIMER;..\HARDWARE\ultra;..\HARDWARE\ATK-M750;..\HARDWARE\GPS;..\HARDWARE\EXTI;..\HARDWARE\KEY
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group MPU6050
    ../MPU6050/: mpu6050.c mpuiic.c
    ../MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/RingBuffer/: RingBuffer.c RingBuffer.h
    ../HARDWARE/UART2/: uart2.c uart2.h
    ../HARDWARE/ultra/: ultra.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ATK-M750/: atk_m750.h atk_m750.c
    ../HARDWARE/GPS/: gps.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/KEY/: key.c
  group MALLOC
    ../MALLOC/: malloc.c malloc.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_dbgmcu.c stm32f10x_tim.c stm32f10x_exti.c
  group README
    ../: README.TXT
